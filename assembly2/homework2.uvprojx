# Keil uVision project homework2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: homework2 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\ARM\ARM Packs\ARM\CMSIS\5.7.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: test.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
