# Keil uVision project homework.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: homework +hex
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: D:\ARM\ARM Packs\ARM\CMSIS\5.7.0\Device\ARM\ARMCM7\Include;D:\ARM\ARM Packs\ARM\CMSIS\5.7.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.s vars.c eg2.s eg3.s eg4.s eg5.s eg6.s main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
