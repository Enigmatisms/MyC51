# Keil uVision project wechat.uvproj, settings and files
target sss (MCS-51)
  device: AT89C55 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: wechat
  c flags: Optimize=8 SizeSpeed=1
  group Subscriber
    ./: STARTUP.A51 display_module.c utils.c display_module.h utils.h serial_listen.h serial_listen.c subscribe.c
target Target 1 (MCS-51)
  device: AT89C55 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: wechat +hex
  c flags: Optimize=8 SizeSpeed=1
