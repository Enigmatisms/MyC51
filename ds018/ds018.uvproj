# Keil uVision project ds018.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: ds018 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 append_module.c append_module.h utils.h utils.c dynamic.c
